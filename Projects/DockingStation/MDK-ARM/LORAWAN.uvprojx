# Keil uVision project LORAWAN.uvprojx, settings and files
target ClassC (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L151CBxxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LORAWAN +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA REGION_US915_HYBRID
  c include: ../Inc;../../../Drivers\STM32L1xx_HAL_Driver\Inc;../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../Drivers/CMSIS/Include;../../../LoraLib\Utilities;../../../LoraLib\Core;../../../LoraLib\Crypto;../../../LoraLib\Mac;../../../LoraLib\Mac\region;../../../LoraLib\Phy;../../../Drivers\sx1276;../../../Drivers\sx1276mb1las
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group Application/User
    ../Src/: main.c bsp.c vcom.c hw_gpio.c stm32l1xx_it.c stm32l1xx_hal_msp.c
    ../src/: hw.c hw_rtc.c hw_spi.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_dma.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group LoraLib/Core
    ../../../LoraLib/Core/: lora.c lora-test.c
  group LoraLib/Mac
    ../../../LoraLib/Mac/: LoRaMac.c LoRaMacCrypto.c
  group LoraLib/Mac/Region
    ../../../LoraLib/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group LoraLib/Utilites
    ../../../LoraLib/Utilities/: low_power_manager.c timeServer.c delay.c utilities.c
  group LoraLib/Crypto
    ../../../LoraLib/Crypto/: aes.c cmac.c
  group Drivers/SX1276
    ../../../Drivers/sx1276/: sx1276.c
  group Drivers/sx1276mb1las
    ../../../Drivers/sx1276mb1las/: sx1276mb1las.c
software components: CMSIS:CORE 4.3.0
