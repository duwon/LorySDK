# IAR project LORAWAN.ewp, settings and files
configuration LORAWAN (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xBA ST STM32L151xBA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xBA; REGION_US915_HYBRID
  ICCARM.CCIncludePath2: ../Inc; ..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc\Legacy; ..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\LoraLib\Utilities; ..\..\..\LoraLib\Core; ..\..\..\LoraLib\Crypto; ..\..\..\LoraLib\Mac; ..\..\..\LoraLib\Mac\region; ..\..\..\LoraLib\Phy; ..\..\..\Drivers\sx1276; ..\..\..\Drivers\sx1276mb1las
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LORAWAN.hex
  ILINK.IlinkOutputFile: LORAWAN.out
  ILINK.IlinkIcfFile: stm32l151xba_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l151xba.s
  group Application/User
    ../src/: bsp.c hw.c hw_gpio.c hw_rtc.c hw_spi.c main.c stm32l1xx_hal_msp.c stm32l1xx_it.c vcom.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_cortex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c
  group Drivers/SX1276
    ../../../Drivers/sx1276/: sx1276.c
  group Drivers/sx1276mb1las
    ../../../Drivers/sx1276mb1las/: sx1276mb1las.c
  group LoraLib/Core
    ../../../LoraLib/Core/: lora-test.c lora.c
  group LoraLib/Crypto
    ../../../LoraLib/Crypto/: aes.c cmac.c
  group LoraLib/Mac
    ../../../LoraLib/Mac/: LoRaMac.c LoRaMacCrypto.c
  group LoraLib/Mac/Region
    ../../../LoraLib/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group LoraLib/Utilities
    ../../../LoraLib/Utilities/: delay.c low_power_manager.c timeServer.c utilities.c
